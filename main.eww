<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\main.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\uCOS-III-Ex4\uCOS-III-Ex4.ewp</path>
    </project>
    <batchBuild />
</workspace>
