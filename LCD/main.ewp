# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: font.h hardware.h lcd.c lcd.h main.c
  group Libraries/CMSIS
    Libraries/CMSIS/: core_cm3.c core_cm3.h misc.c misc.h stm32f10x.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_it.c stm32f10x_it.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_usart.c stm32f10x_usart.h system_stm32f10x.c system_stm32f10x.h
    ./: stm32f10x_lib.h
